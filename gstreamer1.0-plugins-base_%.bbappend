RDEPENDS_libgstgl-1.0 += "sunxi-mali"
RDEPENDS_${PN}-opengl += "sunxi-mali"
